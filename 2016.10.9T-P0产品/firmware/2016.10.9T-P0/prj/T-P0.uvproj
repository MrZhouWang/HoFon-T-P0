# Keil uVision project T-P0.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W1K16S STC
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FF8) CLOCK(35000000) MODP2
  output: T-P0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc;..\prj;..\src
  group Source Group 1
    ./: STARTUP.A51
  group inc
    ../inc/: 820A0.h 820A2.h 820A4.h 820A10S.h 910U_P0.h 910U_P3.h 910U_P6.h 910U_P10.h 920U_P3.h 920U_P6.h ASCII_LED.H eeprom.h extern_symbol.h Glob.h key.h led.h MAIN.H mytype.h process.h STC_NEW_8051.H STC15Fxxxx.H uart.h
  group src
    ../src/: crc.c eeprom.c key.c led.c main.c process.c uart.c
