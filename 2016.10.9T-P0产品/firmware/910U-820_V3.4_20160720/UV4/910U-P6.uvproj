# Keil uVision project 910U-P6.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: 910U-P0_V3_4_15W1K16S_20161009 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: eeprom.c key.c led.c main.c uart.c process.c crc.c
